# Keil uVision project Motion_test.uvprojx, settings and files
target Motion_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Motion_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Can
    ./Can_driver/: CAN.h CAN_conf.h CAN.c
  group Pwm
    ./PWM_driver/: PWM.c PWM.h PWM_conf.h
  group Gpio
    ../Motion_Led/Gpio_driver/: GPIO.c GPIO.h GPIO_conf.h
  group Motion
    ./Motion_driver/: Motion_App.h Motion_app_conf.h Motion_App.c
  group Main
    ./: main.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
