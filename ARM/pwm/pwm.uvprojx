# Keil uVision project pwm.uvprojx, settings and files
target pwm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pwm
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: main.c Pwm.c Pwm_PBcfg.c Det.c
  group inc
    ./: Pwm.h Pwm_Cfg.h Pwm_reg.h Common_Macros.h Platform_Types.h Compiler.h Std_Types.h Det.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
