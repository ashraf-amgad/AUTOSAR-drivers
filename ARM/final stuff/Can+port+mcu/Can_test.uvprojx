# Keil uVision project Can_test.uvprojx, settings and files
target Can (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Can_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: main.c IRQ.c Can.c Can_Irq.c Can_PBcfg.c MCU.c Mcu_PBcfg.c Det.c Port.c Port_PBcfg.c
  group inc
    ./: Can.h Can_Cfg.h Can_reg.h Mcu.h Mcu_Cfg.h Mcu_Cbk.h MCU_Regs.h IRQ.h Can_GeneralTypes.h ComStack_Types.h Platform_Types.h Std_Types.h Compiler.h Common_Macros.h CanIf_Cbk.h EcuM_Cbk.h Det.h Dio_Regs.h Port.h Port_Cfg.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
